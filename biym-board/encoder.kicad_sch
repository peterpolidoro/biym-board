File: biym-board/encoder.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U2 AS5047P

Commit message: Update to kicad 7
Other:
- title: biym-board-encoder -> biym-board
